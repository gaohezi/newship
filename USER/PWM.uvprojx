# Keil uVision project PWM.uvprojx, settings and files
target PWM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\USART3;..\HARDWARE\ML302;..\HARDWARE\ADC;..\HARDWARE\REMOTE;..\HARDWARE\POWER;..\HARDWARE\RTC;..\HARDWARE\FLASH;..\HARDWARE\WDG;..\HARDWARE\UART5;..\HARDWARE\EXTI;..\HARDWARE\RS485;..\HARDWARE\IIC;..\HARDWARE\AHT20;..\HARDWARE\SHT31;..\HARDWARE\UART5;..\HARDWARE\JY901;..\HARDWARE\USART2;..\HARDWARE\CRC;..\HARDWARE\GPS;..\HARDWARE\SYSTICK;..\HARDWARE\JSON
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/POWER/: power.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/ML302/: ml302.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/SHT31/: sht31.c
    ../HARDWARE/UART5/: uart5.c
    ../HARDWARE/RS485/: rs485.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/CRC/: crc16.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/SYSTICK/: systick.c
    ../HARDWARE/JSON/: json.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_bkp.c stm32f10x_fsmc.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_iwdg.c
  group README
    ../: README.TXT
